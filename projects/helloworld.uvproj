# Keil uVision project helloworld.uvproj, settings and files
target helloworld (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: helloworld +hex
  c flags: Optim=1
  c define: BUILD_BIN,AOS_NO_WIFI,CONFIG_NO_TCPIP,OSAL_RHINO,AOS_HAL,USE_HAL_DRIVER,AOS_COMP_RHINO,AOS_COMP_DEBUG,AOS_COMP_ULOG,AOS_COMP_VFS,MCU_FAMILY="mcu_stm32f1xx"
  c misc: -DSTM32F103xB -DSYSINFO_PRODUCT_MODEL="ALI_AOS_stm32f103rb-nucleo" -DSYSINFO_DEVICE_NAME="NUCLEO-F103RB" -DSYSINFO_OS_VERSION="" -DSYSINFO_ARCH="ARM_Cortex-M3" -DSYSINFO_MCU="STM32F103RBTx"
  c include: ../app/example/blink/;../board/stm32f103rb-nucleo/;../board/stm32f103rb-nucleo/config/;../board/stm32f103rb-nucleo/drivers/;../osal/aos/;../platform/mcu/stm32f1xx/hal;../platform/mcu/stm32f1xx/hal/include;../platform/mcu/stm32f1xx/drivers/STM32F1xx_HAL_Driver/Inc;../platform/mcu/stm32f1xx/drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../platform/mcu/stm32f1xx/drivers/CMSIS/Include;../platform/mcu/stm32f1xx/drivers/CMSIS/Device/ST/STM32F1xx/Include;../kernel/init/include;../kernel/rhino/include;../kernel/rhino/;../kernel/debug/;../kernel/debug/include;../platform/arch/arm/armv7m/common/;../middleware/uagent/ulog/include;../kernel/fs/vfs/;../kernel/fs/vfs/include;../include;../include/hal;../include/hal/soc;../include/network;../utility/libc/compilers/armlibc/;../network/yloop/include;../network/yloop/hal
  asm misc: --cpreproc
  asm include: ../board/stm32f103rb-nucleo/config;../kernel/debug/include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/example/blink/: blink.c
    ../app/example/helloworld/: helloworld.c
  group board_config
    ../board/stm32f103rb-nucleo/config/: k_config.c partition_conf.c
  group board_drivers
    ../board/stm32f103rb-nucleo/drivers/: stm32f1xx_hal_msp.c system_stm32f1xx.c
  group board_startup
    ../board/stm32f103rb-nucleo/startup/: board.c startup.c startup_stm32f103xb.s startup_stm32f103xb_iar.s startup_stm32f103xb_keil.s
  group osal_aos
    ../osal/aos/: cli.c common.c kv.c mbmaster.c rhino.c vfs.c vfs_.c
  group platform_mcu_drivers
    ../platform/mcu/stm32f1xx/drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_msp_template.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_timebase_rtc_alarm_template.c stm32f1xx_hal_timebase_tim_template.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group platform_mcu_hal
    ../platform/mcu/stm32f1xx/hal/: hal_adc_stm32f1.c hal_flash_stm32f1.c hal_gpio_stm32f1.c hal_i2c_stm32f1.c hal_nand_stm32f1.c hal_nor_stm32f1.c hal_qspi_stm32f1.c hal_rtc_stm32f1.c hal_sd_stm32f1.c hal_spi_stm32f1.c hal_timer_stm32f1.c hal_uart_stm32f1.c hw.c
  group kernel_init
    ../kernel/init/: aos_init.c
  group kernel_rhino
    ../kernel/rhino/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_spin_lock.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group kernel_debug
    ../kernel/debug/: debug_backtrace.c debug_cpuusage.c debug_infoget.c debug_overview.c debug_panic.c
  group platform_arch_armv7m
    ../platform/arch/arm/armv7m/armcc/m3/: port_s.S
    ../platform/arch/arm/armv7m/common/: panic_c.c port_c.c panic_armcc.S
  group utility_libc
    ../utility/libc/compilers/armlibc/: armcc_libc.c hal_stub.c
  group middleware_uagent_ulog
    ../middleware/uagent/ulog/: log.c session_fs.c session_udp.c ulog.c ulog_init.c uring_fifo.c
  group kernel_fs_vfs
    ../kernel/fs/vfs/: vfs.c vfs_adapt.c vfs_file.c vfs_inode.c
  group network_yloop_hal
    ../network/yloop/hal/: loop_hal_alios.c
  group network_yloop
    ../network/yloop/src/: device.c local_event.c select.c workqueue.c yloop.c
